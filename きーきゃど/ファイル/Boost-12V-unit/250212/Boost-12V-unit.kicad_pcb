# Repository Toin-Sigma/rcj-backups

## KiCad design きーきゃど/ファイル/Boost-12V-unit/250212/Boost-12V-unit.kicad_pcb

Parts:
C1, C13, C25, C37: 220uF, 25V; CP_Radial_D6.3mm_P2.50mm
C2, C3, C4, C14, C23, C24, C26, C35, C36, C38, C47, C48: 47uF, 16V; CP_Elec_5x5.8
C5, C19, C31, C43: 4.7uF, 10V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C21, C33, C45: 470pF, 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C22, C34, C46: 4700pF, 50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C8, C12, C16, C17, C28, C29, C40, C41: 0.1uF, 35V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C11, C15, C20, C27, C32, C39, C44: 1uF, 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C18, C30, C42: 0.047uF, 50V; C_Disc_D3.8mm_W2.6mm_P2.50mm
J1, J2, J3, J4: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
L1, L2, L3, L4: 2.2uH; [L](2.2uH)FDA1055-H-2R2M
R1: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R2, R8, R14, R20: 100k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3, R9, R15, R21: 18k, 1/10W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R10, R16, R22: 150k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R5, R12, R18, R24: 430k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R6, R11, R17, R23: 900k, 1/10W; R_1206_3216Metric
R7, R13, R19: 220k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW1, SW2, SW3, SW4, SW5: [device][sw](toggle5p)2MS1-T1-B4-VS2-Q-E-S
U1, U2, U3, U4: [device]tps61088
U5, U6: [pad]3

Connections:
unnamed: C16.2, C17.2, L2.2, R7.1, U2.4 (SW), U2.5 (SW), U2.6 (SW), U2.7 (SW)
unnamed: C22.1, R9.2
unnamed: C28.2, C29.2, L3.2, R13.1, U3.4 (SW), U3.5 (SW), U3.6 (SW), U3.7 (SW)
unnamed: C34.1, R15.2
unnamed: C40.2, C41.2, L4.2, R19.1, U4.4 (SW), U4.5 (SW), U4.6 (SW), U4.7 (SW)
unnamed: C46.1, R21.2
unnamed: R11.2, R12.1
unnamed: R17.2, R18.1
unnamed: R23.2, R24.1
unnamed: C8.1, C12.1, U1.8 (BOOT)
unnamed: C5.1, U1.1 (Vcc), U1.2 (EN)
unnamed: C10.1, U1.10 (SS)
unnamed: C16.1, C17.1, U2.8 (BOOT)
unnamed: C21.1, R9.1, U2.18 (COMP)
unnamed: C19.1, U2.1 (Vcc), U2.2 (EN)
unnamed: R10.2, R11.1, U2.17 (FB)
unnamed: R7.2, U2.3 (FSW)
unnamed: R8.1, U2.19 (ILIM)
unnamed: C18.1, U2.10 (SS)
unnamed: C28.1, C29.1, U3.8 (BOOT)
unnamed: C33.1, R15.1, U3.18 (COMP)
unnamed: C31.1, U3.1 (Vcc), U3.2 (EN)
unnamed: R16.2, R17.1, U3.17 (FB)
unnamed: R13.2, U3.3 (FSW)
unnamed: R14.1, U3.19 (ILIM)
unnamed: C30.1, U3.10 (SS)
unnamed: C40.1, C41.1, U4.8 (BOOT)
unnamed: C45.1, R21.1, U4.18 (COMP)
unnamed: C43.1, U4.1 (Vcc), U4.2 (EN)
unnamed: R22.2, R23.1, U4.17 (FB)
unnamed: R19.2, U4.3 (FSW)
unnamed: R20.1, U4.19 (ILIM)
unnamed: C42.1, U4.10 (SS)
Vin+: C1.1, C2.1, C9.1, C13.1, C14.1, C15.1, C25.1, C26.1, C27.1, C37.1, C38.1, C39.1, J1.2, L1.1, L2.1, L3.1, L4.1, SW1.2 (B), SW1.3 (C), U1.9 (Vin), U2.9 (Vin), U3.9 (Vin), U4.9 (Vin), U5.3 (IN), U6.3 (IN)
Vout2+: C20.1, C23.1, C24.1, J2.2, R12.2, SW2.2 (B), SW2.3 (C), U2.14 (Vout), U2.15 (Vout), U2.16 (Vout), U5.2 (OUT2)
Vout3+: C32.1, C35.1, C36.1, J3.1, R18.2, SW5.2 (B), SW5.3 (C), U3.14 (Vout), U3.15 (Vout), U3.16 (Vout), U6.1 (OUT1)
Vout4+: C44.1, C47.1, C48.1, J3.2, R24.2, SW3.2 (B), SW3.3 (C), U4.14 (Vout), U4.15 (Vout), U4.16 (Vout), U6.2 (OUT2)

Notes on the sheet:
R23 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V
R17 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V
R6 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V
R11 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V

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
Board: 4 copper layers, 84.1 x 70.6 mm, 96 parts (18 on the bottom side), 47 nets.

Other parts of the board:
R25, R26, R27, R28, R29: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

## KiCad design きーきゃど/ファイル/Power-unit/241227/Power-unit.kicad_pcb

Parts:
C1: 1000μF-35V; CP_Radial_D12.5mm_P5.00mm
C2, C4: 22μ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C5: 10μ; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C7: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED; LED_0603_1608Metric
F1: Fuse-15A; mini-fuse-holder
J1: from-battery; [hole]vin
J2: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J3: Conn_01x10_Pin; JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
OKLT6W12C1, OKLT6W12C2: [device][DCDC]OKL-T6-W12
R1: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R2, R3, R4, R5, R6, R7, R8: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R9, R14: 20k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R10, R15: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R11, R16: 330; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R12, R17: 10; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R13, R18: 1.2k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R19: 75; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW1: sw_B; [hole]2p
SW2: motor-start; [device][sw](toggle5p)2MS1-T1-B4-VS2-Q-E-S
SW3: move_at-gk; [device][sw](toggle5p)2MS1-T1-B4-VS2-Q-E-S
SW4: goal_blue-yellow; [device][sw](toggle5p)2MS1-T1-B4-VS2-Q-E-S
SW5: NeoPixel_on-off; [device][sw](toggle5p)2MS1-T1-B4-VS2-Q-E-S
SW6: sw_A; [device][sw](tact)(2pVertical)TVBP06-b043CW-B
SW7: sw_B; [device][sw](tact)(2pVertical)TVBP06-b043CW-B
SW8: sw_C; [device][sw](tact)(2pVertical)TVBP06-b043CW-B
U2: SOT-223-3_TabPin2

Connections:
+3.3V: C7.2, J3.2, R1.1, U2.2 (OUT)
+5V: C3.1, C6.1, J3.1, OKLT6W12C1.4 (Vout), OKLT6W12C1.5 (Sense), R13.1, R19.1, U2.3 (VIN)
+5V_Line: C5.1, J2.1, OKLT6W12C2.4 (Vout), OKLT6W12C2.5 (Sense), R18.1
+9V: C1.1, C2.1, C4.1, OKLT6W12C1.2 (Vin), OKLT6W12C2.2 (Vin), R9.1, R14.1, SW1.2 (B)
+v: F1.1, J1.1
+v-fuse: F1.2, SW1.1 (A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, D1.1 (K), J1.2, J2.2, J3.10, OKLT6W12C1.1 (ON/OFF), OKLT6W12C1.3 (GND), OKLT6W12C1.7 (GND), OKLT6W12C2.1 (ON/OFF), OKLT6W12C2.3 (GND), OKLT6W12C2.7 (GND), R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R12.2, R13.2, R14.2, R17.2, R18.2, U2.1 (GND)
unnamed: D1.2 (A), R19.2
unnamed: OKLT6W12C1.6 (Trim), R10.1
unnamed: OKLT6W12C2.6 (Trim), R15.1
unnamed: R10.2, R11.1
unnamed: R11.2, R12.1
unnamed: R15.2, R16.1
unnamed: R16.2, R17.1
unnamed: R1.2, SW2.2 (B), SW2.3 (C), SW3.2 (B), SW3.3 (C), SW4.2 (B), SW4.3 (C), SW5.2 (B), SW5.3 (C), SW6.1 (A), SW7.1 (A), SW8.1 (A)
at-gk: J3.4, R3.1, SW3.1 (A)
motor-start: J3.3, R2.1, SW2.1 (A)
neopixel: J3.6, R5.1, SW5.1 (A)
swA: J3.7, R6.1, SW6.2 (B)
swB: J3.8, R7.1, SW7.2 (B)
swC: J3.9, R8.1, SW8.2 (B)
whichgoal: J3.5, R4.1, SW4.1 (A)

Board: 4 copper layers, 56.5 x 70.6 mm, 42 parts (24 on the bottom side), 22 nets.

## KiCad design きーきゃど/ファイル/Boost-selfmade-unit/241226/Boost-selfmade-unit.kicad_pcb

Parts:
C1: 47uF; CP_Elec_5x5.4
C2, C3: 1uF; [C]1206-3216
C4, C5: 50V2200uF; CP_Radial_D16.0mm_P7.50mm
C6, C7, C8, C10: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 0.47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11, C12: 0.33μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: 60V2A; D_SOD-323_HandSoldering
J1, J2, J3: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J5: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L1: 33uF4.8A; L_Radial_D12.0mm_P5.00mm_Neosid_SD12_style2
Q1: NMOS; [TO]TO-252
Q2: NMOS; [TO]SOT-23
R1: 1k; [R]1206-3216
R2: 36k; [R]1206-3216
R3, R4, R6: 10k; [R]1206-3216
R5: 100k; [R]1206-3216
R7, R8: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U3: SOT-23-5_HandSoldering
U2, U4: TLP2361; SO-6_4.4x3.6mm_P1.27mm
U5, U6, U9, U10: [pad]small
U7, U8: tssp58038; [device][sensor]tssp58038
XL1: [module]XL6009
XL6009E1: [device]XL6009E1

Connections:
+5V: C6.1, C7.1, J4.1, J5.1, R3.1, U1.5 (Vin), U2.6 (Vin), U3.5 (Vin), U4.6 (Vin), U7.3 (VCC), U8.3 (VCC)
+9V: J1.1, U5.1 (IN), U6.1 (IN)
+50V: C3.1, C4.1, C5.1, D1.1 (K), D2.2 (A), R2.2, XL1.3 (OUT+)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.1, C11.2, C12.2, J1.2, J2.2, J4.3, J5.3, Q1.3 (S), Q2.3 (S), R1.1, R4.1, R5.1, R6.1, U1.3 (GND), U2.3 (cathode), U2.4 (GND), U3.3 (GND), U4.3 (cathode), U4.4 (GND), U7.2 (GND), U8.2 (GND), XL1.2 (IN-), XL1.4 (OUT-), XL6009E1.1 (GND)
unnamed: C8.2, C9.1
unnamed: D1.2 (A), L1.2, XL6009E1.3 (SW)
unnamed: D2.1 (K), J3.1
unnamed: C10.2, Q1.2 (G), R6.2, U2.5 (Vout)
unnamed: C9.2, Q2.2 (G), R5.2
unnamed: U1.4 (DATAout), U2.1 (anode)
unnamed: U3.4 (DATAout), U4.1 (anode)
unnamed: C8.1, R4.2, U4.5 (Vout)
unnamed: C1.1, C2.1, L1.1, U5.2 (OUT), XL6009E1.2 (EN), XL6009E1.4 (Vin)
unnamed: U6.2 (OUT), XL1.1 (IN+)
unnamed: R7.2, U7.1 (OUT)
unnamed: R8.2, U8.1 (OUT)
unnamed: U3.2 (DATAin), U10.2 (OUT)
unnamed: R1.2, R2.1, XL6009E1.5 (FB)
ballcatch_left: C12.1, J5.2, R8.1
ballcatch_right: C11.1, J4.2, R7.1
ground: J3.2, Q1.1 (D)
signal-first: J2.1, U9.1 (IN), U10.1 (IN)
signal-second: Q2.1 (D), R3.2, U1.2 (DATAin), U9.2 (OUT)

Notes on the sheet:
OUTPUT
Signal protection
Vout = 1.25 * (1 + R2 / R1)
One-Shot
XL6009 Module
INPUT

Board: 2 copper layers, 92.6 x 64.8 mm, 42 parts (0 on the bottom side), 23 nets.
