# Repository Toin-Sigma/rcj-backups

## KiCad design きーきゃど/ファイル/Boost-12V-unit/241026/Boost-12V-unit.kicad_pcb

Parts:
C1, C13, C25, C37: 220uF, 25V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2, C3, C4, C14, C23, C24, C26, C35, C36, C38, C47, C48: 47uF, 16V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C5, C19, C31, C43: 4.7uF, 10V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6, C21, C33, C45: 470pF, 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7, C22, C34, C46: 4700pF, 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C8, C12, C16, C17, C28, C29, C40, C41: 0.1uF, 35V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C9, C11, C15, C20, C27, C32, C39, C44: 1uF, 25V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C10, C18, C30, C42: 0.047uF, 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J1: Conn_01x02_Pin; 2pin
J2, J4, J6, J8: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
L1, L2, L3, L4: 2.2uH; FDA1055-H-2R2M
R1, R7, R13, R19: 220k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R2, R8, R14, R20: 100k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3, R9, R15, R21: 18k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R4, R10, R16, R22: 150k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R5, R12, R18, R24: 430k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R6, R11, R17, R23: 900k, 1/10W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U1, U2, U3, U4: tps61088

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, J1.1, J2.1, J4.1, J6.1, J8.1, R2.2, R4.1, R8.2, R10.1, R14.2, R16.1, R20.2, R22.1, U1.11 (NC), U1.12 (NC), U1.13 (MODE), U1.20 (AGND), U1.21 (PGND), U2.11 (NC), U2.12 (NC), U2.13 (MODE), U2.20 (AGND), U2.21 (PGND), U3.11 (NC), U3.12 (NC), U3.13 (MODE), U3.20 (AGND), U3.21 (PGND), U4.11 (NC), U4.12 (NC), U4.13 (MODE), U4.20 (AGND), U4.21 (PGND)
unnamed: C7.1, R3.2
unnamed: C8.2, C12.2, L1.2, R1.1, U1.4 (SW), U1.5 (SW), U1.6 (SW), U1.7 (SW)
unnamed: C16.2, C17.2, L2.2, R7.1, U2.4 (SW), U2.5 (SW), U2.6 (SW), U2.7 (SW)
unnamed: C22.1, R9.2
unnamed: C28.2, C29.2, L3.2, R13.1, U3.4 (SW), U3.5 (SW), U3.6 (SW), U3.7 (SW)
unnamed: C34.1, R15.2
unnamed: C40.2, C41.2, L4.2, R19.1, U4.4 (SW), U4.5 (SW), U4.6 (SW), U4.7 (SW)
unnamed: C46.1, R21.2
unnamed: R5.1, R6.2
unnamed: R11.2, R12.1
unnamed: R17.2, R18.1
unnamed: R23.2, R24.1
unnamed: C8.1, C12.1, U1.8 (BOOT)
unnamed: C6.1, R3.1, U1.18 (COMP)
unnamed: C5.1, U1.1 (Vcc), U1.2 (EN)
unnamed: R4.2, R6.1, U1.17 (FB)
unnamed: R1.2, U1.3 (FSW)
unnamed: R2.1, U1.19 (ILIM)
unnamed: C10.1, U1.10 (SS)
unnamed: C16.1, C17.1, U2.8 (BOOT)
unnamed: C21.1, R9.1, U2.18 (COMP)
unnamed: C19.1, U2.1 (Vcc), U2.2 (EN)
unnamed: R10.2, R11.1, U2.17 (FB)
unnamed: R7.2, U2.3 (FSW)
unnamed: R8.1, U2.19 (ILIM)
unnamed: C18.1, U2.10 (SS)
unnamed: C28.1, C29.1, U3.8 (BOOT)
unnamed: C33.1, R15.1, U3.18 (COMP)
unnamed: C31.1, U3.1 (Vcc), U3.2 (EN)
unnamed: R16.2, R17.1, U3.17 (FB)
unnamed: R13.2, U3.3 (FSW)
unnamed: R14.1, U3.19 (ILIM)
unnamed: C30.1, U3.10 (SS)
unnamed: C40.1, C41.1, U4.8 (BOOT)
unnamed: C45.1, R21.1, U4.18 (COMP)
unnamed: C43.1, U4.1 (Vcc), U4.2 (EN)
unnamed: R22.2, R23.1, U4.17 (FB)
unnamed: R19.2, U4.3 (FSW)
unnamed: R20.1, U4.19 (ILIM)
unnamed: C42.1, U4.10 (SS)
Vin+: C1.1, C2.1, C9.1, C13.1, C14.1, C15.1, C25.1, C26.1, C27.1, C37.1, C38.1, C39.1, J1.2, L1.1, L2.1, L3.1, L4.1, U1.9 (Vin), U2.9 (Vin), U3.9 (Vin), U4.9 (Vin)
Vout1+: C3.1, C4.1, C11.1, J2.2, R5.2, U1.14 (Vout), U1.15 (Vout), U1.16 (Vout)
Vout2+: C20.1, C23.1, C24.1, J4.2, R12.2, U2.14 (Vout), U2.15 (Vout), U2.16 (Vout)
Vout3+: C32.1, C35.1, C36.1, J6.2, R18.2, U3.14 (Vout), U3.15 (Vout), U3.16 (Vout)
Vout4+: C44.1, C47.1, C48.1, J8.2, R24.2, U4.14 (Vout), U4.15 (Vout), U4.16 (Vout)

Notes on the sheet:
R23 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V
R17 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V
R6 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V
R11 について Vout = 1.204 * { 1 + ( R6 + 430) / 150 } R6 の値が 900k のとき、 Vout の値は 約11.88V

Board: 2 copper layers, 85 parts (0 on the bottom side), 46 nets, no tracks yet.

## KiCad design きーきゃど/ファイル/Boost-selfmade-unit/241227/Boost-selfmade-unit.kicad_pcb

Board: 2 copper layers, 92.6 x 64.8 mm, 42 parts (0 on the bottom side), 23 nets.

Parts:
C1: 47uF; CP_Elec_5x5.4
C2, C3: 1uF; [C]1206-3216
C4, C5: 50V2200uF; CP_Radial_D16.0mm_P7.50mm
C6, C7, C8, C10: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 0.47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11, C12: 0.33μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: 60V2A; D_SOD-323_HandSoldering
J1, J2, J3: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J5: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L1: 33uF4.8A; L_Radial_D12.0mm_P5.00mm_Neosid_SD12_style2
Q1: NMOS; [TO]TO-252
Q2: NMOS; [TO]SOT-23
R1: 1k; [R]1206-3216
R2: 36k; [R]1206-3216
R3, R4, R6: 10k; [R]1206-3216
R5: 100k; [R]1206-3216
R7, R8: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U3: SOT-23-5_HandSoldering
U2, U4: TLP2361; SO-6_4.4x3.6mm_P1.27mm
U5, U6, U9, U10: [pad]small
U7, U8: tssp58038; [device][sensor]tssp58038
XL1: [module]XL6009
XL6009E1: [device]XL6009E1

Connections:
+5V: C6.1, C7.1, J4.1, J5.1, R3.1, U1.5 (Vin), U2.6 (Vin), U3.5 (Vin), U4.6 (Vin), U7.3 (VCC), U8.3 (VCC)
+9V: J1.1, U5.1 (IN), U6.1 (IN)
+50V: C3.1, C4.1, C5.1, D1.1 (K), D2.2 (A), R2.2, XL1.3 (OUT+)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.1, C11.2, C12.2, J1.2, J2.2, J4.3, J5.3, Q1.3 (S), Q2.3 (S), R1.1, R4.1, R5.1, R6.1, U1.3 (GND), U2.3 (cathode), U2.4 (GND), U3.3 (GND), U4.3 (cathode), U4.4 (GND), U7.2 (GND), U8.2 (GND), XL1.2 (IN-), XL1.4 (OUT-), XL6009E1.1 (GND)
unnamed: C8.2, C9.1
unnamed: D1.2 (A), L1.2, XL6009E1.3 (SW)
unnamed: D2.1 (K), J3.1
unnamed: C10.2, Q1.2 (G), R6.2, U2.5 (Vout)
unnamed: C9.2, Q2.2 (G), R5.2
unnamed: U1.4 (DATAout), U2.1 (anode)
unnamed: U3.4 (DATAout), U4.1 (anode)
unnamed: C8.1, R4.2, U4.5 (Vout)
unnamed: C1.1, C2.1, L1.1, U5.2 (OUT), XL6009E1.2 (EN), XL6009E1.4 (Vin)
unnamed: U6.2 (OUT), XL1.1 (IN+)
unnamed: R7.2, U7.1 (OUT)
unnamed: R8.2, U8.1 (OUT)
unnamed: U3.2 (DATAin), U10.2 (OUT)
unnamed: R1.2, R2.1, XL6009E1.5 (FB)
ballcatch_left: C12.1, J5.2, R8.1
ballcatch_right: C11.1, J4.2, R7.1
ground: J3.2, Q1.1 (D)
signal-first: J2.1, U9.1 (IN), U10.1 (IN)
signal-second: Q2.1 (D), R3.2, U1.2 (DATAin), U9.2 (OUT)

## KiCad design きーきゃど/ファイル/Boost-unit/241026/Boost-unit.kicad_pcb

Board: 2 copper layers, 85.1 x 55.4 mm, 14 parts (0 on the bottom side), 12 nets.

Parts:
3300uF, 3300uF#2: 50V3300uF; CP_Radial_D16.0mm_P7.50mm
C3, C4: 0.1uF; RPEF11H104Z2P1A01B
Inverter: SOT-23-5_HandSoldering
Inverter#2: SOT-23-5_HandSoldering
J1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2, J3: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
NMOS: NMOS; SOT-23_Handsoldering
Q2: NMOS; 2SK4033
TLP261, TLP2361: TLP2361; SO-6_4.4x3.6mm_P1.27mm
XL6009: XL6009

Connections:
+3.3V: C3.1, C4.1, Inverter.5 (Vin), Inverter#2.5 (Vin), J2.2, TLP261.6 (Vin), TLP2361.6 (Vin)
+9V: J2.1, NMOS.1 (D)
+48V: J1.1, Q2.3 (S)
GND: 3300uF.2, 3300uF#2.2, C3.2, C4.2, Inverter.3 (GND), Inverter#2.3 (GND), J1.2, J2.3, J3.3, TLP261.3 (cathode), TLP261.4 (GND), TLP2361.3 (cathode), TLP2361.4 (GND), XL6009.2 (IN-), XL6009.4 (OUT-)
HIGH / LOW 1: Inverter.2 (DATAin), J3.1
HIGH / LOW 2: Inverter#2.2 (DATAin), J3.2
unnamed: NMOS.2 (G), TLP261.5 (Vout)
unnamed: NMOS.3 (S), XL6009.1 (IN+)
unnamed: 3300uF.1, 3300uF#2.1, Q2.1 (D), XL6009.3 (OUT+)
unnamed: Q2.2 (G), TLP2361.5 (Vout)
unnamed: Inverter.4 (DATAout), TLP261.1 (anode)
unnamed: Inverter#2.4 (DATAout), TLP2361.1 (anode)

## KiCad design きーきゃど/ファイル/MD-unit/241026/MD-unit.kicad_pcb

Board: 4 copper layers, 56.5 x 70.6 mm, 15 parts (0 on the bottom side), 16 nets.

Parts:
C1, C2, C3, C4: 16V470μF; CP_Radial_D8.0mm_P3.50mm
J1: Conn_01x02_Pin; 2pin
J2: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J3, J4, J5, J6: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
MES1: Voltmeter_DC; VoltMeter
U1, U2, U3, U4: DRV8874

Connections:
+3.3V: J2.6, U1.6 (SLEEP), U2.6 (SLEEP), U3.6 (SLEEP), U4.6 (SLEEP)
+9V: C1.1, C2.1, C3.1, C4.1, J1.1, MES1.2 (+), U1.14 (VIN), U2.14 (VIN), U3.14 (VIN), U4.14 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, J1.2, MES1.1 (-), U1.2 (GND), U1.5 (PMODE), U1.13 (GND), U2.2 (GND), U2.5 (PMODE), U2.13 (GND), U3.2 (GND), U3.5 (PMODE), U3.13 (GND), U4.2 (GND), U4.5 (PMODE), U4.13 (GND)
M1out1: J3.1, U1.12 (OUT1)
M1out2: J3.2, U1.11 (OUT2)
M2out1: J4.1, U2.12 (OUT1)
M2out2: J4.2, U2.11 (OUT2)
M3out1: J5.1, U3.12 (OUT1)
M3out2: J5.2, U3.11 (OUT2)
M4out1: J6.1, U4.12 (OUT1)
M4out2: J6.2, U4.11 (OUT2)
pwm1: J2.1, U1.4 (FN/IN2)
pwm2: J2.2, U2.4 (FN/IN2)
pwm3: J2.3, U3.4 (FN/IN2)
pwm4: J2.4, U4.4 (FN/IN2)
sig: J2.5, U1.3 (FN/IN1), U2.3 (FN/IN1), U3.3 (FN/IN1), U4.3 (FN/IN1)

## KiCad design きーきゃど/ファイル/Neopixel-unit/241026/NeoPixel-unit.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R1: 75Ω; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
WS2812B1, WS2812B2, WS2812B3, WS2812B4, WS2812B5, WS2812B6, WS2812B7, WS2812B8, WS2812B9, WS2812B10, WS2812B11, WS2812B12, WS2812B13, WS2812B14, WS2812B15, WS2812B16, WS2812B17, WS2812B18, WS2812B19, WS2812B20, WS2812B21, WS2812B22, WS2812B23, WS2812B24, WS2812B25, WS2812B26, WS2812B27, WS2812B28, WS2812B29, WS2812B30, WS2812B31, WS2812B32: WS2812B

Connections:
+5V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, J1.1, R1.1, WS2812B1.1 (VDD), WS2812B2.1 (VDD), WS2812B3.1 (VDD), WS2812B4.1 (VDD), WS2812B5.1 (VDD), WS2812B6.1 (VDD), WS2812B7.1 (VDD), WS2812B8.1 (VDD), WS2812B9.1 (VDD), WS2812B10.1 (VDD), WS2812B11.1 (VDD), WS2812B12.1 (VDD), WS2812B13.1 (VDD), WS2812B14.1 (VDD), WS2812B15.1 (VDD), WS2812B16.1 (VDD), WS2812B17.1 (VDD), WS2812B18.1 (VDD), WS2812B19.1 (VDD), WS2812B20.1 (VDD), WS2812B21.1 (VDD), WS2812B22.1 (VDD), WS2812B23.1 (VDD), WS2812B24.1 (VDD), WS2812B25.1 (VDD), WS2812B26.1 (VDD), WS2812B27.1 (VDD), WS2812B28.1 (VDD), WS2812B29.1 (VDD), WS2812B30.1 (VDD), WS2812B31.1 (VDD), WS2812B32.1 (VDD)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, D1.1 (K), J1.3, WS2812B1.3 (VSS), WS2812B2.3 (VSS), WS2812B3.3 (VSS), WS2812B4.3 (VSS), WS2812B5.3 (VSS), WS2812B6.3 (VSS), WS2812B7.3 (VSS), WS2812B8.3 (VSS), WS2812B9.3 (VSS), WS2812B10.3 (VSS), WS2812B11.3 (VSS), WS2812B12.3 (VSS), WS2812B13.3 (VSS), WS2812B14.3 (VSS), WS2812B15.3 (VSS), WS2812B16.3 (VSS), WS2812B17.3 (VSS), WS2812B18.3 (VSS), WS2812B19.3 (VSS), WS2812B20.3 (VSS), WS2812B21.3 (VSS), WS2812B22.3 (VSS), WS2812B23.3 (VSS), WS2812B24.3 (VSS), WS2812B25.3 (VSS), WS2812B26.3 (VSS), WS2812B27.3 (VSS), WS2812B28.3 (VSS), WS2812B29.3 (VSS), WS2812B30.3 (VSS), WS2812B31.3 (VSS), WS2812B32.3 (VSS)
unnamed: D1.2 (A), R1.2
unnamed: WS2812B1.2 (DOUT), WS2812B2.4 (DIN)
unnamed: WS2812B2.2 (DOUT), WS2812B3.4 (DIN)
unnamed: WS2812B3.2 (DOUT), WS2812B4.4 (DIN)
unnamed: WS2812B4.2 (DOUT), WS2812B5.4 (DIN)
unnamed: WS2812B5.2 (DOUT), WS2812B6.4 (DIN)
unnamed: WS2812B7.2 (DOUT), WS2812B8.4 (DIN)
unnamed: WS2812B8.2 (DOUT), WS2812B9.4 (DIN)
unnamed: WS2812B9.2 (DOUT), WS2812B10.4 (DIN)
unnamed: WS2812B10.2 (DOUT), WS2812B11.4 (DIN)
unnamed: WS2812B11.2 (DOUT), WS2812B12.4 (DIN)
unnamed: WS2812B13.2 (DOUT), WS2812B14.4 (DIN)
unnamed: WS2812B14.2 (DOUT), WS2812B15.4 (DIN)
unnamed: WS2812B15.2 (DOUT), WS2812B16.4 (DIN)
unnamed: WS2812B16.2 (DOUT), WS2812B17.4 (DIN)
unnamed: WS2812B17.2 (DOUT), WS2812B18.4 (DIN)
unnamed: WS2812B19.2 (DOUT), WS2812B20.4 (DIN)
unnamed: WS2812B20.2 (DOUT), WS2812B21.4 (DIN)
unnamed: WS2812B21.2 (DOUT), WS2812B22.4 (DIN)
unnamed: WS2812B22.2 (DOUT), WS2812B23.4 (DIN)
unnamed: WS2812B23.2 (DOUT), WS2812B24.4 (DIN)
unnamed: WS2812B25.2 (DOUT), WS2812B26.4 (DIN)
unnamed: WS2812B26.2 (DOUT), WS2812B27.4 (DIN)
unnamed: WS2812B27.2 (DOUT), WS2812B28.4 (DIN)
unnamed: WS2812B28.2 (DOUT), WS2812B29.4 (DIN)
unnamed: WS2812B29.2 (DOUT), WS2812B30.4 (DIN)
unnamed: WS2812B31.2 (DOUT), WS2812B32.4 (DIN)
data1: WS2812B6.2 (DOUT), WS2812B7.4 (DIN)
data2: WS2812B12.2 (DOUT), WS2812B13.4 (DIN)
data3: WS2812B18.2 (DOUT), WS2812B19.4 (DIN)
data4: WS2812B24.2 (DOUT), WS2812B25.4 (DIN)
data5: WS2812B30.2 (DOUT), WS2812B31.4 (DIN)
sig: J1.2, WS2812B1.4 (DIN)

Board: 2 copper layers, 95.0 x 95.0 mm, 67 parts (33 on the bottom side), 35 nets.
